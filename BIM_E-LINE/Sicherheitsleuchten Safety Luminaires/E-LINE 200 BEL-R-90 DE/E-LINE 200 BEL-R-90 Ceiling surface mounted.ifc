Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: eabaf5b1-0b4d-4273-83eb-11154dd277fb, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: E-LINE 200 BEL-R-90 Ceiling surface mounted.ifc
Time: 2024-10-24T10:18:21+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: E-LINE 200 BEL-R-90 Ceiling surface mounted:E-LINE 200 BEL-R-90 DE LED 2W - 230, E-LINE 200 BEL-R-90 Ceiling surface mounted:E-LINE 200 BEL-R-90 DE LED 2W - 230:2518104
In: Default
Type - Material: Kunststoff - PC RAL9016, Kunststoff -PVC, Vorgabe_1
Type - Pset_ElementShading - Color: white
Material: Vorgabe_1
Pset_DistributionFlowElementCommon - Reference: E-LINE 200 BEL-R-90 DE LED 2W - 230; sets with these values: 2

Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 8038691f-2d7d-4d76-9643-d8fe3840d13c, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: E-LINE 200 DES - 1W.ifc
Time: 2024-10-24T08:23:26+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: E-LINE 200 DES:E-LINE 200 DES LED 1W - 230, E-LINE 200 DES:E-LINE 200 DES LED 1W - 230:2518122
In: Default
Type - Material: Kunststoff - PC RAL9016, Kunststoff - PMMA, Kunststoff -PVC, Vorgabe_1
Type - Pset_ElementShading - Color: white
Material: Vorgabe_1
Pset_DistributionFlowElementCommon - Reference: E-LINE 200 DES LED 1W - 230; sets with these values: 2
